		AREA RESET,DATA,READONLY
		EXPORT __Vectors
__Vectors
		DCD 0x10001000
		DCD Reset_Handler
		ALIGN
		AREA mycode,CODE,READONLY
		ENTRY
		EXPORT Reset_Handler
Reset_Handler
		LDR R0,=NUM
		LDR R1,=FACTORIAL
		LDR R2,[R0]
		MOV R3,#1
		BL FACT
		STR R3,[R1]
STOP	B STOP
FACT	PUSH {R2,LR}
		SUB R2,#1
		CMP R2,#1
		BNE DOWN
		B DOWN1
DOWN	BL FACT
DOWN1	POP {R2,LR}
		MUL R3,R2
		BX LR
NUM DCD 5
		AREA mydata,DATA,READWRITE
FACTORIAL DCD 0
		END