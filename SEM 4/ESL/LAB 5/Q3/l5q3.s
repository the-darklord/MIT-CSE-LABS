		AREA RESET,DATA,READONLY
		EXPORT __Vectors
__Vectors
		DCD 0x10001000
		DCD Reset_Handler
		ALIGN
		AREA mycode,CODE,READONLY
		ENTRY
		EXPORT Reset_Handler
Reset_Handler
		LDR R0,=ARRAY
		LDR R1,=FLAG
		LDR R2,=POS
		MOV R5,#0
		MOV R4,#0
COMP	LDR R3,[R0],#4
		ADD R4,#1
		CMP R3,#0x4
		BEQ FOUND
		CMP R4,#5
		BNE COMP
STORE	ADD R4,#1
		STR R5,[R1]
		STR R4,[R2]
STOP	B STOP
FOUND	ADD R5,#1
		SUB R4,#1
		B STORE
ARRAY DCD 1,2,3,4,5
		AREA mydata,DATA,READWRITE
FLAG DCD 0
POS DCD 0
		END