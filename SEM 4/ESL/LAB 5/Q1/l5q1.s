		AREA RESET,DATA,READONLY
		EXPORT __Vectors
__Vectors
		DCD 0x10001000
		DCD Reset_Handler
		ALIGN
		AREA mycode,CODE,READONLY
		ENTRY
		EXPORT Reset_Handler
Reset_Handler
		LDR R0,=ARRAY
		MOV R9,#0
		MOV R10,#0
L2		MOV R1,R0
		MOV R3,R0
		ADD R3,#1
		ADD R10,R9,#1
L1		LDRB R4,[R3]
		LDRB R5,[R1]
		CMP R4,R5
		BCS DOWN
		MOV R1,R3
DOWN	ADD R3,#1
		ADD R10,#1
		CMP R10,#5
		BNE L1
		LDRB R2,[R0]
		LDRB R6,[R1]
		STRB R2,[R1]
		STRB R6,[R0]
		ADD R0,#1
		ADD R9,#1
		CMP R9,#4
		BNE L2
		LDR R0,=ARRAY
STOP	B STOP
		AREA mydata,DATA,READWRITE
ARRAY DCB 0
		END