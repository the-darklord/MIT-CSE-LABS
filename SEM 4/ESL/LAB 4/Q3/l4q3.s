		AREA RESET, DATA, READONLY
		EXPORT __Vectors		
__Vectors
		DCD 0X10001000
		DCD Reset_Handler
		ALIGN
		AREA mycode, CODE, READONLY
		ENTRY
		EXPORT Reset_Handler
Reset_Handler
		LDR R0, =NUM1
		LDR R1, =NUM2
		LDR R2, =RES
		MOV R4,#0
		LDR R5,[R0]
		LDR R6,[R1]
UP 		MOV R7,R5
		MOV R8,R6
		AND R7,#0xF
		ADDS R7,R4
		MOV R4,#0
		AND R8,#0xF
		BL ADDN
		LSR R5,#4
		LSR R6,#4
		CMP R5,#0
		BEQ DOWN
		B UP
DOWN	CMP R6,#0
		BEQ TUPAC
		B UP
ADDN	ADDS R7,R8
		CMP R7,#0xA
		BCC STORE
		SUB R7,#0xA
		ADD R6,#01
STORE 	STRB R7,[R2],#1
		BX LR
TUPAC	MOV R0,R2
		LDR R2, =RES
		LDR R3, =PACK
		SUB R4,R0,R2
UP1		LDRB R0,[R2],#1
		LDRB R1,[R2],#1
		LSL R1,#4
		ORR R1,R0
		STRB R1,[R3],#1
		SUB R4,#2
		CMP R4,#1
		BGE UP1
STOP 	B STOP

NUM1 DCD 0x45
NUM2 DCD 0x11
		AREA mydata, DATA, READWRITE
RES DCD 0
PACK DCD 0
	END